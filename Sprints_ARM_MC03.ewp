# IAR project Sprints_ARM_MC03.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Appl
    Appl/: main.c
  group Common
    Common/: Compiler.h Mcu_Hw.h Platform_Types.h Std_Types.h
  group Config
    Config/: IntCtrl_Cfg.h IntCtrl_Lcfg.c
  group Mcal
    Mcal/: IntCtrl.c IntCtrl.h IntCtrl_Types.h
